# IAR project ble_thread_router_wireless_uart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; gTotalHeapSize_c=15616; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; FRDM_KW41Z512; gLedRgbEnabled_d=1; gLEDsOnTargetBoardCnt_c=4; gKBD_TsiElectdCount_c=2; gKBD_KeysCount_c=4; gHybridApp_d=1; STACK_THREAD=1; gMacFeatureSet_d=gMacFeatureSet_THR_M0_d
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/hybrid/ble_thread_router_wireless_uart/config/config.h
  ICCARM.CCIncludePath2: ../../../../../../../middleware/wireless/framework_5.3.2/common/rtos/freertos/config; ../../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM0; ../../../../../../../rtos/freertos_8.2.3/Source/include; ../../../../common; ../../../../../../../devices/MKW41Z4; ../../../../../../../devices/MKW41Z4/drivers; ../../../../../../../CMSIS/Include; ../../../../../../../devices/MKW41Z4/utilities; ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/hybrid/common/src; ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/hybrid/ble_thread_router_wireless_uart/src; ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common/gatt_db/macros; ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common/gatt_db; ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common; ../../../../../../../middleware/wireless/framework_5.3.2/Common; ../../../../../../../middleware/wireless/framework_5.3.2/DCDC/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/FSCI/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/FSCI/Source; ../../../../../../../middleware/wireless/framework_5.3.2/FunctionLib; ../../../../../../../middleware/wireless/framework_5.3.2/GPIO; ../../../../../../../middleware/wireless/framework_5.3.2/Keyboard/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/LED/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/Lists; ../../../../../../../middleware/wireless/framework_5.3.2/MemManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/Messaging/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/ModuleInfo; ../../../../../../../middleware/wireless/framework_5.3.2/MWSCoexistence/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/NVM/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/NVM/Source; ../../../../../../../middleware/wireless/framework_5.3.2/OSAbstraction/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/OtaSupport/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/Panic/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/RNG/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/SecLib; ../../../../../../../middleware/wireless/framework_5.3.2/SerialManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/SerialManager/Source; ../../../../../../../middleware/wireless/framework_5.3.2/SerialManager/Source/SPI_Adapter; ../../../../../../../middleware/wireless/framework_5.3.2/SerialManager/Source/USB_VirtualNic; ../../../../../../../middleware/wireless/framework_5.3.2/Shell/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/TimersManager/Interface; ../../../../../../../middleware/wireless/framework_5.3.2/TimersManager/Source; ../../../../../../../middleware/wireless/framework_5.3.2/Flash/Internal; ../../../../../../../middleware/wireless/framework_5.3.2/Flash/External/Interface; ../../../../../../../middleware/wireless/nwk_ip_1.2.0/base/interface; ../../../../../../../middleware/wireless/nwk_ip_1.2.0/core/interface; ../../../../../../../middleware/wireless/nwk_ip_1.2.0/core/interface/modules; ../../../../../../../middleware/wireless/nwk_ip_1.2.0/core/interface/thread; ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/common; ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/battery; ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/device_info; ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/wireless_uart; ../../../../../../../middleware/wireless/bluetooth_1.2.2/controller/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.2/hci_transport/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.2/host/interface; ../../../../../../../middleware/wireless/bluetooth_1.2.2/host/config; ../../../../../../../middleware/wireless/framework_5.3.2/LowPower/Interface/MKW41Z; ../../../../../../../middleware/wireless/framework_5.3.2/LowPower/Source/MKW41Z; ../../../../../../../middleware/wireless/framework_5.3.2/XCVR/MKW41Z4; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.2/phy/interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.2/Phy/Source/MKW41Z; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.2/phy/interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.2/mac/interface; ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.2/mac/source/app
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../../middleware/wireless/framework_5.3.2/common/rtos/freertos/config; ../../../../../../../middleware/wireless/framework_5.3.2/common/rtos/freertos/config
  ILINK.IlinkOutputFile: ble_thread_router_wireless_uart.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; gUseBootloaderLink_d=0; __ram_vector_table__=1; gNVMSectorCountLink_d=32; gUseInternalStorageLink_d=0
  ILINK.IlinkIcfFile: ../../../../../../../middleware/wireless/framework_5.3.2/common/devices/MKW41Z4/linker/iar/MKW41Z512xxx4_connectivity.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; gTotalHeapSize_c=15616; CPU_MKW41Z512VHT4; FSL_RTOS_FREE_RTOS; FRDM_KW41Z512; gLedRgbEnabled_d=1; gLEDsOnTargetBoardCnt_c=4; gKBD_TsiElectdCount_c=2; gKBD_KeysCount_c=4; gHybridApp_d=1; STACK_THREAD=1; gMacFeatureSet_d=gMacFeatureSet_THR_M0_d
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group free-rtos
    ../../../../../../../rtos/freertos_8.2.3/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_1.c
  group free-rtos/portable
    ../../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group free-rtos/config
    ../../../../../../../middleware/wireless/framework_5.3.2/common/rtos/freertos/config/: freertosconfig.h
  group ksdk/devices/MKW41Z4
    ../../../../../../../devices/MKW41Z4/iar/: startup_MKW41Z4.s
    ../../../../../../../devices/MKW41Z4/: system_MKW41Z4.c system_MKW41Z4.h
  group ksdk/drivers
    ../../../../../../../devices/MKW41Z4/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.c fsl_common.h fsl_cop.c fsl_cop.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_edma.c fsl_edma.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_ltc.c fsl_ltc.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rtc.c fsl_rtc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_tpm.c fsl_tpm.h fsl_trng.c fsl_trng.h fsl_tsi_v4.c fsl_tsi_v4.h
  group bluetooth/host/lib
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/host/lib/: ble_4-2_host_cm0p_IAR.a
  group bluetooth/host/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/host/interface/: att_errors.h ble_constants.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_types.h smp_types.h vendor_debug_commands.h
  group bluetooth/host/config
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/host/config/: ble_config.h ble_globals.c
  group bluetooth/controller/lib
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/controller/lib/: ble_kw41z_controller_lib_IAR.a
  group bluetooth/controller/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/controller/interface/: controller_interface.h
  group bluetooth/profiles/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/battery/: battery_interface.h
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/device_info/: device_info_interface.h
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/wireless_uart/: wireless_uart_interface.h
  group bluetooth/profiles/battery
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/battery/: battery_service.c
  group bluetooth/profiles/device_info
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/device_info/: device_info_service.c
  group bluetooth/profiles/wireless_uart
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/profiles/wireless_uart/: wireless_uart_service.c
  group bluetooth/hci_transport/interface
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/hci_transport/interface/: hci_transport.h
  group bluetooth/hci_transport/source
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/hci_transport/source/: hcit_serial_interface.c
  group ieee_802_15_4
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.2/mac/lib/: 802.15.4_mac_thr_cm0_iar.a
  group ieee_802_15_4/PHY/Source/MKW41Z
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.2/PHY/Source/MKW41Z/: ASP.c MPM.c Phy.h PhyISR.c PhyPacketProcessor.c PhyPlmeData.c PhyStateMachine.c PhyTime.c
  group ieee_802_15_4/PHY/Interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.2/PHY/Interface/: AspInterface.h MpmInterface.h PhyDebug.h PhyInterface.h PhyMessages.h PhyTypes.h
  group ieee_802_15_4/App
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.2/mac/Source/App/: FsciAspCommands.c FsciAspCommands.h FsciMacCommands.c FsciMacCommands.h MacGlobals.c MacGlobals.h
  group ieee_802_15_4/MAC/Interface
    ../../../../../../../middleware/wireless/ieee_802_15_4_5.3.2/MAC/Interface/: MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group framework/SecLib
    ../../../../../../../middleware/wireless/framework_5.3.2/SecLib/: lib_crypto_IAR_M0.a SecLib.c SecLib.h
  group framework/Common
    ../../../../../../../middleware/wireless/framework_5.3.2/Common/: EmbeddedTypes.h FwkInit.c
  group framework/DCDC/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/DCDC/Source/: DCDC.c
  group framework/FSCI/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/FSCI/Interface/: FsciInterface.h
  group framework/FSCI/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/FSCI/Source/: FsciCommands.c FsciCommands.h FsciCommunication.c FsciCommunication.h FsciLogging.c FsciMain.c
  group framework/FunctionLib
    ../../../../../../../middleware/wireless/framework_5.3.2/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/GPIO
    ../../../../../../../middleware/wireless/framework_5.3.2/GPIO/: GPIO_Adapter.h GPIO_Adapter.c
  group framework/Keyboard/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/LED/Source/: LED.c
  group framework/Lists
    ../../../../../../../middleware/wireless/framework_5.3.2/Lists/: GenericList.h GenericList.c
  group framework/MemManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/Messaging/Source/: Messaging.c
  group framework/ModuleInfo
    ../../../../../../../middleware/wireless/framework_5.3.2/ModuleInfo/: ModuleInfo.h
  group framework/NVM/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/NVM/Interface/: NVM_Interface.h
  group framework/NVM/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework/MWSCoexistence/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/MWSCoexistence/Source/: MWS.c
  group framework/OSAbstraction/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/OSAbstraction/Interface/: fsl_os_abstraction.h
  group framework/OSAbstraction/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/OSAbstraction/Source/: fsl_os_abstraction_free_rtos.c
  group framework/OtaSupport/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/OtaSupport/Interface/: OtaSupport.h
  group framework/OtaSupport/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/OtaSupport/Source/: OtaSupport.c
  group framework/Panic/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/Panic/Source/: Panic.c
  group framework/Reset
    ../../../../../../../middleware/wireless/framework_5.3.2/Reset/: Reset.c
  group framework/RNG/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/RNG/Source/: RNG.c
  group framework/SerialManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/SerialManager/Source/: I2C_Adapter.c I2C_Adapter.h SerialManager.c UART_Adapter.c UART_Adapter.h
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../middleware/wireless/framework_5.3.2/SerialManager/Source/SPI_Adapter/: SPI_Adapter.c SPI_Adapter.h
  group framework/Shell/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/Shell/Interface/: shell.h shell_config.h
  group framework/Shell/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/Shell/Source/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
  group framework/TimersManager/Interface
    ../../../../../../../middleware/wireless/framework_5.3.2/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h
  group framework/Flash/Internal
    ../../../../../../../middleware/wireless/framework_5.3.2/Flash/Internal/: Flash_Adapter.c Flash_Adapter.h
  group framework/Flash/External/Source
    ../../../../../../../middleware/wireless/framework_5.3.2/Flash/External/Source/: Eeprom_AT26DF081A.c Eeprom_AT45DB021E.c Eeprom_AT45DB161E.c Eeprom_AT45DB041E.c Eeprom_InternalFlash.c
  group framework/LowPower/Interface/MKW41Z
    ../../../../../../../middleware/wireless/framework_5.3.2/LowPower/Interface/MKW41Z/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/Source/MKW41Z
    ../../../../../../../middleware/wireless/framework_5.3.2/LowPower/Source/MKW41Z/: PWR.c PWRLib.c PWRLib.h
  group framework/XCVR/MKW41Z4
    ../../../../../../../middleware/wireless/framework_5.3.2/XCVR/MKW41Z4/: fsl_common.h fsl_xcvr.c fsl_xcvr.h fsl_xcvr_ant_config.c fsl_xcvr_ble_config.c fsl_xcvr_common_config.c fsl_xcvr_gfsk_bt_0p3_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p32_config.c fsl_xcvr_gfsk_bt_0p5_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p7_config.c fsl_xcvr_gfsk_bt_0p5_h_1p0_config.c fsl_xcvr_gfsk_bt_0p7_h_0p5_config.c fsl_xcvr_mode_datarate_config.c fsl_xcvr_msk_config.c fsl_xcvr_zgbe_config.c ifr_radio.c ifr_radio.h dbg_ram_capture.h dbg_ram_capture.c fsl_xcvr_trim.h fsl_xcvr_trim.c
  group nwk_ip/core/lib/thread
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/core/lib/thread/: thread_m0_iar.a
  group nwk_ip/core/interface
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/core/interface/: network_utils.h sockets.h stack_events.h
  group nwk_ip/core/interface/thread
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/core/interface/thread/: thread_app_callbacks.h thread_network.h thread_network_data.h thread_attributes.h thread_cfg.h thread_types.h thread_mgmt.h thread_utils.h thread_meshcop.h thread_meshcop_mgmt.h
  group nwk_ip/core/interface/modules
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/core/interface/modules/: arp.h coap.h coap_cfg.h dhcp.h dhcp_cfg.h dhcp_client.h dhcp_server.h dhcp6.h dhcp6_cfg.h dhcp6_client.h dhcp6_lq_client.h dhcp6_lq_server.h dhcp6_relay_agent.h dhcp6_server.h dns_client.h dns_client_cfg.h dns_utils.h dtls.h dtls_cfg.h event_manager.h event_manager_cfg.h icmp.h icmp4.h icmp6.h igmp.h ip.h ip4.h ip6.h ip_cfg.h ip_if_management.h mdns.h mdns_cfg.h mle.h mle_basic.h mle_cfg.h mle_extended.h mle_security.h mle_utils.h mpl.h mpl_cfg.h nd.h nd_cfg.h nd_events.h nd_tables.h nd_sixlowpan.h pmtu_discovery.h rfc4944_6lowpan.h rfc6282_header_comp.h session.h sixlowpan.h sixlowpan_cfg.h sixlowpan_fwd_thread.h sixlowpan_ib.h sixlowpan_interface.h sixlowpan_tbl.h sockets_cfg.h stack_config.h stack_manager_if.h tcp.h tcp_cfg.h thread_stack_config.h trickle.h trickle_cfg.h udp.h udp_cfg.h version.h
  group nwk_ip/base/thci
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/base/thci/: thci.c
  group nwk_ip/base/ip_media_if
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/base/ip_media_if/: ip_if_6lo.c ip_if_enet.c ip_if_usbenet.c
  group nwk_ip/base/shell
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/base/shell/: shell_ip.c
  group nwk_ip/base/stack_globals
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/base/stack_globals/: arp_globals.c coap_globals.c dhcp_globals.c dns_globals.c dtls_globals.c event_manager_globals.c ip_globals.c icmp_globals.c mdns_globals.c mle_globals.c mpl_globals.c nd_globals.c sixlowpan_globals.c sockets_globals.c tcp_globals.c thread_globals.c trickle_globals.c udp_globals.c
  group nwk_ip/base/thread_config
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/base/thread_config/: thread_config.c
  group nwk_ip/base/utils
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/base/utils/: debug_log.c mac_abs_802154.c mac_filtering.c nv_data.c nvm_adapter.c stack_start.c
  group nwk_ip/base/http
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/base/http/: http_server.c http_client.c http.c
  group nwk_ip/base/interface
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/base/interface/: debug_log.h thci.h i2c_abstraction.h ip_if_6LowPan.h ip_if_enet.h ip_if_serial_tun.h mac_abs_802154.h mac_abs_types.h mac_filtering.h mac_filtering_cfg.h nvm_adapter.h nv_data.h shell_ip.h http_cfg.h http.h
  group board
    ../../../../common/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h hardware_init.c board.h board.c
  group app/hybrid/thread_router_bluetooth_wireless_uart_hybrid/config
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/hybrid/ble_thread_router_wireless_uart/config/: config.h
  group app/hybrid/thread_router_bluetooth_wireless_uart_hybrid/src
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/hybrid/ble_thread_router_wireless_uart/src/: thread_router_bluetooth_wireless_uart_hybrid_app.h thread_router_bluetooth_wireless_uart_hybrid_app.c gatt_uuid128.h gatt_db.h app_config.c app.h app.c
  group app/hybrid/common/src
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/hybrid/common/src/: ble_init.h ble_init.c ApplMain.h ApplMain.c
  group app/bluetooth/common
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common/: ble_host_tasks.c ble_host_task_config.h ble_controller_task_config.h ble_controller_task.c ble_conn_manager.h ble_conn_manager.c ble_service_discovery.h ble_service_discovery.c
  group app/bluetooth/common/gatt_db
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common/gatt_db/: gatt_db_handles.h gatt_database.c
  group app/bluetooth/common/gatt_db/macros
    ../../../../../../../middleware/wireless/bluetooth_1.2.2/examples/common/gatt_db/macros/: gatt_uuid_def_x.def gatt_uuid_decl_x.def gatt_size_x.def gatt_init_x.def gatt_enum_x.def gatt_decl_x.def gatt_db_x_macros.def gatt_db_macros.h gatt_alloc_x.def
  group app/thread/common/config
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/common/: app_config.h app_framework_config.h app_mac_config.h app_stack_config.h app_thread_config.h
  group app/thread/common/src/app_observe_demo
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/common/: app_observe_demo.c app_observe_demo.h
  group app/thread/common/src/app_coap_observe
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/common/: app_coap_observe.c app_coap_observe.h
  group app/thread/common/src/app_echo_udp
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/common/: app_echo_udp.c app_echo_udp.h
  group app/thread/common/src/app_event_monitoring
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/common/: app_event_monitoring.c app_event_monitoring.h
  group app/thread/common/src/app_socket_utils
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/common/: app_socket_utils.c app_socket_utils.h
  group app/thread/common/src/app_temp_sensor
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/common/: app_temp_sensor.c app_temp_sensor.h
  group app/thread/common/src/app_init
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/common/: app_init.c app_init.h
  group app/thread/common/src/app_thread
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/common/: app_thread_callbacks.c app_thread_init.c
  group app/thread/common/src/app_led
    ../../../../../../../middleware/wireless/nwk_ip_1.2.0/examples/common/: app_led.c app_led.h
